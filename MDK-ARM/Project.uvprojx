# Keil uVision project Project.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV
  c include: ..\Inc;..\Libraries\CMSIS\Include;..\Libraries\BSP\AIR001_Core_Board;..\Libraries\CMSIS\Device\AIR001xx\Include;..\Libraries\AIR001xx_HAL_Driver\Inc;..\MDK-ARM;..\Libraries\BSP\I2C;..\Libraries\BSP\OLED;..\Libraries\BSP\UART;..\Libraries\BSP\EEPROM;..\Libraries\BSP\battary
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_air001_dev.s
    ../Src/: system_air001xx.c
  group User
    ../Src/: main.c air001xx_hal_msp.c air001xx_it.c
  group BSP
    ../Libraries/BSP/I2C/: I2C.c
    ../Libraries/BSP/OLED/: OLED.c ui.c
    ../Src/: key.c
    ../Libraries/BSP/UART/: uart.c
    ../Libraries/BSP/EEPROM/: at24c02.c
    ../Libraries/BSP/battary/: cw2015.c
  group HAL_Drivers
    ../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_dma.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_uart.c air001xx_hal_pwr.c
software components: CMSIS:CORE 5.6.0
